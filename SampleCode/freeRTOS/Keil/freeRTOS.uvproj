# Keil uVision project freeRTOS.uvproj, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC120VE3DN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUC100Series\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
    ../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
  group User
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c
  group FreeRTOS
    ../Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Source/portable/RVDS/ARM_CM0/: port.c
    ../Source/portable/MemMang/: heap_2.c
